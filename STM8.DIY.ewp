# IAR project STM8.DIY.ewp, settings and files
configuration STM8L051F3.RF_LT8920.TX (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x000
  ICCSTM8.CCDefines: STM8L05X_LD_VL; __TX__; __RF_LT8920__
  ICCSTM8.CCIncludePath2: Sources
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8.DIY.srec
  ILINK.IlinkOutputFile: STM8.DIY.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8L051F3.RF_LT8920.RX (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL; __RX__; __RF_LT8920__
configuration STM8L051F3.RF_NRF24L01P.TX (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL; __TX__
configuration STM8L051F3.RF_NRF24L01P.RX (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL; __RX__
  group (top)
    Sources/: Config.c Config.h main.c
  group Application
    Sources/Application/: Application.c Application.h
  group Application/Command
    Sources/Application/Command/: Command.c Command.h Command.Struct.h
  group Application/Control
    Sources/Application/Control/: Control.c Control.Enum.h Control.h Control.Struct.h
  group Application/LED
    Sources/Application/LED/: LED.c LED.h
  group Application/Servos
    Sources/Application/Servos/: Servos.c Servos.Enum.h Servos.h Servos.Struct.h
  group Driver
    Sources/Driver/: Driver.c Driver.h
  group Driver/Driver.STM8L15x
    Sources/Driver/Driver.STM8L15x/: Driver.STM8L15x.c Driver.STM8L15x.Define.h Driver.STM8L15x.h stm8l15x.h stm8l15x_adc.c stm8l15x_adc.h stm8l15x_aes.c stm8l15x_aes.h stm8l15x_beep.c stm8l15x_beep.h stm8l15x_clk.c stm8l15x_clk.h stm8l15x_comp.c stm8l15x_comp.h stm8l15x_conf.h stm8l15x_dac.c stm8l15x_dac.h stm8l15x_dma.c stm8l15x_dma.h stm8l15x_exti.c stm8l15x_exti.h stm8l15x_flash.c stm8l15x_flash.h stm8l15x_gpio.c stm8l15x_gpio.h stm8l15x_i2c.c stm8l15x_i2c.h stm8l15x_irtim.c stm8l15x_irtim.h stm8l15x_it.c stm8l15x_it.h stm8l15x_itc.c stm8l15x_itc.h stm8l15x_iwdg.c stm8l15x_iwdg.h stm8l15x_lcd.c stm8l15x_lcd.h stm8l15x_pwr.c stm8l15x_pwr.h stm8l15x_rst.c stm8l15x_rst.h stm8l15x_rtc.c stm8l15x_rtc.h stm8l15x_spi.c stm8l15x_spi.h stm8l15x_syscfg.c stm8l15x_syscfg.h stm8l15x_tim1.c stm8l15x_tim1.h stm8l15x_tim2.c stm8l15x_tim2.h stm8l15x_tim3.c stm8l15x_tim3.h stm8l15x_tim4.c stm8l15x_tim4.h stm8l15x_tim5.c stm8l15x_tim5.h stm8l15x_usart.c stm8l15x_usart.h stm8l15x_wfe.c stm8l15x_wfe.h stm8l15x_wwdg.c stm8l15x_wwdg.h
  group Services
    Sources/Services/: Services.c Services.h
  group Services/Input
    Sources/Services/Input/: Input.c Input.Define.h Input.Enum.h Input.h Input.Struct.h
  group Services/Output
    Sources/Services/Output/: Output.c Output.Define.h Output.Enum.h Output.h Output.Struct.h
  group Services/RF
    Sources/Services/RF/: RF.c RF.h
  group Services/RF/RF.LT8920
    Sources/Services/RF/RF.LT8920/: RF.LT8920.c RF.LT8920.Cfg.c RF.LT8920.Cfg.h RF.LT8920.Enum.h RF.LT8920.h RF.LT8920.Struct.h
  group Services/RF/RF.NRF24L01P
    Sources/Services/RF/RF.NRF24L01P/: RF.NRF24L01P.c RF.NRF24L01P.h
  group System
    Sources/System/: System.h System.Init.c System.Init.h System.Struct.h System.Task.c System.Task.h
